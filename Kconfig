## Kconfig
```kconfig
config VIDEO_V4L2LOOPBACK
	bool "Enable V4L2 loopback"
	default y
	---help---
          Not required for build i think...
```
